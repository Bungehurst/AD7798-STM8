# IAR project STM8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: Lib\inc; BSP\led; BSP\uart; BSP\AD7798; BSP\spi; USR; BSP\delay; BSP\tim1
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: STM8.hex
  ILINK.IlinkOutputFile: STM8.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group BSP
    BSP/AD7798/: AD7798.c
    BSP/delay/: delay.c
    BSP/led/: led.c
    BSP/spi/: spi.c
    BSP/tim1/: tim1.c
    BSP/uart/: uart.c
  group LIB
    Lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_spi.c stm8s_tim1.c stm8s_uart1.c
  group USR
    USR/: main.c stm8s_conf.h stm8s_it.c
    Lib/inc/: stm8s.h
